# Keil uVision project test.uvprojx, settings and files
target Target (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\cmsis;..\fwlib\inc;..\mylib;..\user
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cmsis
    ../cmsis/: startup_stm32f40_41xxx.s
  group fwlib
    ../fwlib/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c misc.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_iwdg.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_adc.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group user
    ../user/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group mylib
    ../mylib/: led.c relay.c button.c buzzer.c delay.c eint.c wdt.c uart.c lcd.c ds18b20.c ds_gpio.c dht.c adc.c pm25.c rtc.c gpio_iic.c eeprom.c usart4.c esp8266.c
